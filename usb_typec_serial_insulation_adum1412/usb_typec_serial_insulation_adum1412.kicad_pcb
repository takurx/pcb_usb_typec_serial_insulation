# Repository takurx/pcb_usb_typec_serial_insulation

File README.md:

# pcb_usb_typec_serial_insulation
This is pcb, usb type-c serial insulation

## usb_typec_serial_insulation_adum1412
This folder contains the KiCad project files for a USB Type-C serial insulation board using the ADUM1412 digital isolator chip. The project includes schematic files, PCB layout files, and a complete set of Gerber manufacturing files in the gerber subdirectory. This design provides galvanic isolation for serial communication through USB Type-C connections.

## usb_typec_serial_insulation_adum121n
This folder contains the KiCad project files for a USB Type-C serial insulation board using the ADUM121N digital isolator chip. Similar to the ADUM1412 version, it includes complete schematic, PCB layout, and Gerber manufacturing files. This alternative design uses a different isolator IC to achieve serial communication isolation through USB Type-C.

# follow below for Japanese version

## usb_typec_serial_insulation_adum1412
このフォルダには、ADUM1412デジタルアイソレータチップを使用したUSB Type-Cシリアル絶縁基板のKiCadプロジェクトファイルが含まれています。プロジェクトには、回路図ファイル、PCBレイアウトファイル、およびgerberサブディレクトリ内の完全なガーバー製造ファイルセットが含まれています。この設計は、USB Type-C接続を介したシリアル通信のガルバニック絶縁を提供します。

## usb_typec_serial_insulation_adum121n
このフォルダには、ADUM121Nデジタルアイソレータチップを使用したUSB Type-Cシリアル絶縁基板のKiCadプロジェクトファイルが含まれています。ADUM1412バージョンと同様に、完全な回路図、PCBレイアウト、およびガーバー製造ファイルが含まれています。この代替設計では、異なるアイソレータICを使用して、USB Type-Cを介したシリアル通信の絶縁を実現しています。

## KiCad design usb_typec_serial_insulation_adum1412/usb_typec_serial_insulation_adum1412.kicad_pcb

Parts:
C1: 0.1uF,>10V(=5V*2); C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2: 0.1F,>10V(=5V*2); C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
J1, J2: Conn_01x06_Socket; PinHeader_1x06_P2.54mm_Vertical
U1: ADuM1412; SOIC-16W_7.5x10.3mm_P1.27mm

Connections:
GND1: C1.2, J1.6, U1.2 (GND1), U1.8 (GND1)
GND2: C2.2, J2.6, U1.9 (GND2), U1.15 (GND2)
unnamed: J1.1, U1.4 (VIB)
unnamed: J1.2, U1.5 (VOC)
unnamed: J1.3, U1.3 (VIA)
unnamed: J1.5, U1.6 (VOD)
unnamed: J2.1, U1.11 (VID)
unnamed: J2.2, U1.14 (VOA)
unnamed: J2.3, U1.12 (VIC)
unnamed: J2.5, U1.13 (VOB)
VCC1: C1.1, J1.4, U1.1 (VDD1), U1.7 (CTRL1)
VCC2: C2.1, J2.4, U1.10 (CTRL2), U1.16 (VDD2)

Notes on the sheet:
1 VIB, RTS <- 2 VOC, RXD -> 3 VIA, TXD <- 4 VCC 5 VOD, CTS -> 6 GND
ArduinoのUART出力などが接続されることを想定する
Arduino 1 RTS -> 2 RXD <- 3 TXD -> 4 VCC 5 CTS <- 6 GND
J1, J2のピン配置は、 ポカヨケで秋月電子のCH340Eモジュールがどちら側でも付けれるように合わせる Arduinoの場合はArduino側を合わせる
秋月電子のCH340E USBシリアル変換モジュールを接続することを想定する CH340E USBシリアル変換モジュール Type-C: 半導体 秋月電子通商-電子部品・ネット通販 https://akizukidenshi.com/catalog/g/g114745/
1 RTS -> 2 RXD <- 3 TXD -> 4 VCC 5 CTS <- 6 GND
1 VID, RTS -> 2 VOA, RXD <- 3 VIC, TXD -> 4 VCC 5 VOB, CTS <- 6 GND
1 RTS <- 2 RXD -> 3 TXD <- 4 VCC 5 CTS -> 6 GND

Board: 2 copper layers, 27.0 x 17.0 mm, 5 parts (0 on the bottom side), 12 nets.

## KiCad design usb_typec_serial_insulation_adum121n/usb_typec_serial_insulation.kicad_pcb

Parts:
C1, C2: 0.1uF,10V(=5V*2); C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
J1, J2: Conn_01x06_Socket; PinHeader_1x06_P2.54mm_Vertical
U1: ADuM121N; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
GND1: C1.2, J1.6, U1.4 (GND1)
GND2: C2.2, J2.6, U1.5 (GND2)
unnamed: J1.2, U1.2 (VOA)
unnamed: J1.3, U1.3 (VIB)
unnamed: J2.2, U1.6 (VOB)
unnamed: J2.3, U1.7 (VIA)
VCC1: C1.1, J1.4, U1.1 (VDD1)
VCC2: C2.1, J2.4, U1.8 (VDD2)

Notes on the sheet:
1 NC 2 VOA, TXD -> 3 VIB, RXD <- 4 VCC 5 NC 6 GND
ArduinoのUART入出力が接続される場合
秋月電子のCH340E USBシリアル変換モジュールを接続することを想定する CH340E USBシリアル変換モジュール Type-C: 半導体 秋月電子通商-電子部品・ネット通販 https://akizukidenshi.com/catalog/g/g114745/
1 NC 2 VOB, TXD <- 3 VIA, RXD -> 4 VCC 5 NC 6 GND
1 RTS <- 2 RXD -> 3 TXD <- 4 VCC 5 CTS -> 6 GND
1 RTS -> 2 RXD <- 3 TXD -> 4 VCC 5 CTS <- 6 GND
Arduino 1 NC/RTS -> 2 RXD <- 3 TXD -> 4 VCC 5 NC/CTS <- 6 GND
J1, J2のピン配置は、 ポカヨケで秋月電子のCH340Eモジュールがどちら側でも付けれるように合わせる Arduinoの場合はArduino側を合わせる

Board: 2 copper layers, 20.0 x 17.0 mm, 5 parts (0 on the bottom side), 8 nets.

## Commit log (part)

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2026-02-11 add pcb usb typec serial insulation adum121n
    add pcb usb typec serial insulation adum121n
2026-02-12 add C1, C2 adum121N V1.1
    add C1, C2 adum121N V1.1
2026-02-12 add image for description
    add image for description
2026-02-13 add 1412
    add 1412
2026-02-13 add 1412 other plan
    add 1412 other plan
2026-02-13 add readme with cline+claude4.5
    add readme with cline+claude4.5
2026-02-13 ちょっと修正
    ちょっと修正
2026-03-26 modify 121N, V2.0
    modify 121N, V2.0
2026-03-26 modify 1412
    modify 1412
2026-03-26 add silk description
    add silk description
2026-04-30 add pinout description
    add pinout description
